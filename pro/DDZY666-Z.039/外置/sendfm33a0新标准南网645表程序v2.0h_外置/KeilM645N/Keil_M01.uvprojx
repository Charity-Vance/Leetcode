# Keil uVision project Keil_M01.uvprojx, settings and files
target A04_256_24 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM32L020 FMSH
  pack: Keil.FM32LXX_DFP.0.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FFF0073F31992011 +hex
  AfterMake: fromelf.exe --bin --output=out/M01_A04.bin Objects/M01_A04.axf
  AfterMake: cmd.exe /C copy  Objects\M01_A04.hex out\M01_A04.hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __A04
  c misc: --diag_suppress=1296,550
  c include: ..\CM0;..\cpu\FM32L0XX\Device\Include;..\cpu\FM32L0XX\Drivers\Include
  asm define: __A04
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\A04_256_24.sct
  group Device
    ../cpu/FM32L0XX/Drivers/Source/: fm32l0xx_uart.c fm32l0xx_spi.c fm32l0xx_scu.c fm32l0xx_rtc.c fm32l0xx_rcc.c fm32l0xx_nvmif.c fm32l0xx_iwdg.c fm32l0xx_i2c.c fm32l0xx_gpio.c fm32l0xx_dma.c fm32l0xx_anac.c
    ../cpu/FM32L0XX/Device/Source/: system_fm32l0xx_active.c system_fm32l0xx_lowpower.c system_FM32L0XX3.c
    ../cpu/FM32L0XX/Device/Source/ARM/: startup_FM32L0XX.s
  group APP
    ../CM0/: event.c Factory.c i2c.c init.c interrupt.c iokey.c LCD.c mainproc.c money.c rtc.c tariff.c u7816.c uartx.c verify.c UEnergy-at.C
target A04_256_32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM32L020 FMSH
  pack: Keil.FM32LXX_DFP.0.0.6
  cpu: as above
  output: M01_A04 +hex
  AfterMake: as above
  AfterMake: cmd.exe /C copy  Objects\M01_A04.hex out\M01_A04.hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __A04
  c misc: --diag_suppress=1296,550
  c include: as above
  asm define: __A04
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\A04_256_32.sct
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM32L010 FMSH
  pack: Keil.FM32LXX_DFP.0.0.6
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: M01_A04 +hex
  AfterMake: as above
  AfterMake: cmd.exe /C copy  Objects\M01_A04.hex out\M01_A04.hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __A04,__DEBUG
  c misc: --diag_suppress=1296,550
  c include: as above
  asm define: __A04
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\sct\A04_256_24.sct
